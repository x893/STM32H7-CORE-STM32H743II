# Keil uVision project SDRAM_TEST.uvprojx, settings and files
target SDRAM_TEST (6230000::V6.23::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: SDRAM_TEST
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER USER_VECT_TAB_ADDRESS USE_PWR_LDO_SUPPLY STM32H743xx MG_DEVICE=MG_DEVICE_STM32H7 MG_ARCH=MG_ARCH_CUSTOM,USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../I-CUBE-Mongoose/App;../Middlewares/Third_Party/Cesanta_NetworkLibrary/Mongoose;../CANopen/App;../Middlewares/Third_Party/emotas_CANopen/emotas/Config;../Middlewares/Third_Party/emotas_CANopen/emotas/Library/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: bsp_sdram.c main.c gpio.c eth.c fdcan.c fmc.c memorymap.c quadspi.c rng.c sdmmc.c spi.c usart.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Application/User/CANopen/App
    ../CANopen/App/: app_canopen.c
  group Doc
    F:/uProjects/TCP-UART/STM32H743/H743 core board information/SDRAM_TEST/: readme.txt
  group Middlewares/I-CUBE-CANOPEN/CANopen/emotas
    ../Middlewares/Third_Party/emotas_CANopen/emotas/Library/lib/STM32H7/: I-CUBE-CANOPEN_CM7_ARMCC.lib
    ../Middlewares/Third_Party/emotas_CANopen/emotas/Config/: codrv_canbittiming.c gen_objdict.c
  group Middlewares/I-CUBE-CANOPEN/Documentation
    ../Middlewares/Third_Party/emotas_CANopen/emotas/Config/: emotas_CANopen_Slave_doc.txt
    ../Middlewares/Third_Party/emotas_CANopen/emotas/Documentation/: readme.txt
software components: CMSIS:CORE 6.1.0
